<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103T8C6_LCD.ewp</path>
  </project>
  <batchBuild />
</workspace>
