# Keil uVision project Project.uvproj, settings and files
target MDR32F92QI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MDR32F9Q2I Milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MDR32F92QI
  c flags: Optim=2 oTime=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\;..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\..\..\Libraries\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\..\..\Libraries\MDR32F9Qx_StdPeriph_Driver\inc;..\GLCD;..\GLCD\fonts;..\MLT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group User
    ../: main.c MDR32F9Qx_it.c rst.c pwm.c adc.c regulator.c
  group StdPeriph_Driver
    ../../../Libraries/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c MDR32F9Qx_adc.c MDR32F9Qx_dma.c
  group MDK-ARM
    ../: startup_MDR32F9Qx.s
  group RTX
    ../: Retarget.c RTX_Conf_CM.c
  group MLT
    ../MLT/: mlt_lcd.c
